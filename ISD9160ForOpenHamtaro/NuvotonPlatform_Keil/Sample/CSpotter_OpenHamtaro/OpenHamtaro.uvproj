# Keil uVision project OpenHamtaro.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: OpenHamtaro
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\HW;..\..\..\CMSIS\CM0\CoreSupport;..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\Include;..\..\Include\Driver
  link misc: --map --first='boot_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
    ../../../CMSIS/CM0/CoreSupport/: core_cm0.c
  group Src
    ./: WaveRecord.c VR_sep_conti_main.c VR_sep.c
  group Lib
    ./: CSpotterSDK16k24d.lib
    ../../Src/Driver/: retarget.c DrvPDMA.c DrvSYS.c DrvUART.c DrvADC.c DrvFMC.c DrvGPIO.c DrvDPWM.c
    ../../Lib/: SemiHost_Keil.lib
